SUMMARY = "A console-only image that fully supports the target device \
hardware."
LICENSE = "MIT"

inherit core-image


